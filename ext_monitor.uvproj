# Keil uVision project ext_monitor.uvproj, settings and files
target ext_monitor (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ext_monitor +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG
  c misc: --C99
  c include: .\core;.\STM3210X_FWLib\inc;.\user;.\uart;.\common;.\protocol;.\flash;.\ds1302;.\adc;.\time;.\modem
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ./STM3210X_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c
  group uart
    ./uart/: uart.c
  group common
    ./common/: common.c
  group protocol
    ./protocol/: protocol.c
  group flash
    ./flash/: flash.c
  group ds1302
    ./ds1302/: ds1302.c
  group adc
    ./adc/: adc.c
  group time
    ./time/: time.c
  group modem
    ./modem/: modem.c
